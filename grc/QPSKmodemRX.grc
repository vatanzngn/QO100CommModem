options:
  parameters:
    author: Vatan Zengin TA7WRS
    category: '[QO100-Communication Satellite]'
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3.
    generate_options: hb
    id: QO100_QPSKDataModem_RX_nofec
    output_language: python
    title: QPSK DataModem RX NoFEC
  states: {}

blocks:
- name: bb_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: constel
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, -1+1j, -1-1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1j'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_2_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_1_1_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_1_2_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_1_3
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: chan_bw
  id: parameter
  parameters:
    label: Channel BW (Hz)
    type: eng_float
    value: '1500'
  states: {}
- name: costas_bw
  id: parameter
  parameters:
    label: Costas Loop BW
    type: eng_float
    value: '0.02'
  states: {}
- name: digital_additive_scrambler_xx_1
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_1_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_1_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_1_1
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_1_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_decoder_cb_1_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_decoder_cb_1_2_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_decoder_cb_1_3
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_1_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_2_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_3
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: costas_bw
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: symsync_bw
    max_dev: symsync_dev
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: rrc_alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: bb_samp_rate
    sym_rate: bb_samp_rate/sps
    type: ccc
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: Frequency Offset
    type: intx
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: int(samp_rate/bb_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, chan_bw, chan_bw/3)
    type: ccc
  states: {}
- name: logport
  id: parameter
  parameters:
    label: Log Port
    type: intx
    value: '5001'
  states: {}
- name: network_socket_pdu_0_0_0_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: str(port2)
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0_1_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: str(port3)
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0_2_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: str(port4)
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0_3
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: str(port1)
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    comment: Constellation symbols stream for SNR/EVM measurement
    mode: '2'
    port: logport
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: NEEDS GR_SATELLITES
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: const
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: waterfall
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_2_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_3
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: port1
  id: parameter
  parameters:
    label: RX Port 1
    type: intx
    value: '5002'
  states: {}
- name: port2
  id: parameter
  parameters:
    label: RX Port 2
    type: intx
    value: '5003'
  states: {}
- name: port3
  id: parameter
  parameters:
    label: RX Port 3
    type: intx
    value: '5004'
  states: {}
- name: port4
  id: parameter
  parameters:
    label: RX Port 4
    type: intx
    value: '5005'
  states: {}
- name: rrc_alpha
  id: parameter
  parameters:
    label: RRC Alpha
    type: eng_float
    value: '0.35'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '960000'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: sdr_rx
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: symsync_bw
  id: parameter
  parameters:
    label: Symbol Sync BW
    type: eng_float
    value: '0.008'
  states: {}
- name: symsync_dev
  id: parameter
  parameters:
    label: Symbol Sync MaxDev
    type: eng_float
    value: '0.01'
  states: {}
- name: ted_gain
  id: parameter
  parameters:
    label: Expected TED Gain
    type: eng_float
    value: '0.5'
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: rx_demodulated
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: rx_demodulated
  states: {}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: rx_demodulated
  states: {}
- name: virtual_source_2_2_0
  id: virtual_source
  parameters:
    stream_id: rx_demodulated
  states: {}
- name: virtual_source_2_3
  id: virtual_source
  parameters:
    stream_id: rx_demodulated
  states: {}

connections:
- [blocks_multiply_const_vxx_1_0_0, '0', digital_constellation_decoder_cb_1_0_0, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', digital_constellation_decoder_cb_1_1_0, '0']
- [blocks_multiply_const_vxx_1_2_0, '0', digital_constellation_decoder_cb_1_2_0, '0']
- [blocks_multiply_const_vxx_1_3, '0', digital_constellation_decoder_cb_1_3, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_repack_bits_bb_0_1_0, '0', digital_correlate_access_code_xx_ts_0_1_0, '0']
- [blocks_repack_bits_bb_0_2_0, '0', digital_correlate_access_code_xx_ts_0_2_0, '0']
- [blocks_repack_bits_bb_0_3, '0', digital_correlate_access_code_xx_ts_0_3, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_additive_scrambler_xx_1_0, '0']
- [blocks_repack_bits_bb_1_1_0, '0', digital_additive_scrambler_xx_1_1, '0']
- [blocks_repack_bits_bb_1_2_0, '0', digital_additive_scrambler_xx_1_0_0, '0']
- [blocks_repack_bits_bb_1_3, '0', digital_additive_scrambler_xx_1, '0']
- [digital_additive_scrambler_xx_1, '0', pdu_tagged_stream_to_pdu_0_3, '0']
- [digital_additive_scrambler_xx_1_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [digital_additive_scrambler_xx_1_0_0, '0', pdu_tagged_stream_to_pdu_0_2_0, '0']
- [digital_additive_scrambler_xx_1_1, '0', pdu_tagged_stream_to_pdu_0_1_0, '0']
- [digital_constellation_decoder_cb_1_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_1_1_0, '0', blocks_repack_bits_bb_0_1_0, '0']
- [digital_constellation_decoder_cb_1_2_0, '0', blocks_repack_bits_bb_0_2_0, '0']
- [digital_constellation_decoder_cb_1_3, '0', blocks_repack_bits_bb_0_3, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_1_0, '0', blocks_repack_bits_bb_1_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_2_0, '0', blocks_repack_bits_bb_1_2_0, '0']
- [digital_correlate_access_code_xx_ts_0_3, '0', blocks_repack_bits_bb_1_3, '0']
- [digital_costas_loop_cc_0_0, '0', network_tcp_sink_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0, '0']
- [digital_costas_loop_cc_0_0, '0', virtual_sink_3_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [filter_fft_rrc_filter_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, network_socket_pdu_0_0_0_0_0, pdus]
- [pdu_tagged_stream_to_pdu_0_1_0, pdus, network_socket_pdu_0_0_0_1_0, pdus]
- [pdu_tagged_stream_to_pdu_0_2_0, pdus, network_socket_pdu_0_0_0_2_0, pdus]
- [pdu_tagged_stream_to_pdu_0_3, pdus, network_socket_pdu_0_0_0_3, pdus]
- [satellites_rms_agc_0, '0', filter_fft_rrc_filter_0_0, '0']
- [satellites_rms_agc_0, '0', pad_sink_0_0, '0']
- [sdr_rx, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_2_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [virtual_source_2_1_0, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [virtual_source_2_2_0, '0', blocks_multiply_const_vxx_1_2_0, '0']
- [virtual_source_2_3, '0', blocks_multiply_const_vxx_1_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
