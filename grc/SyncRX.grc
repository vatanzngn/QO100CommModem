options:
  parameters:
    author: Vatan Zengin TA7WRS, PE4WJ, EA4GPZ
    category: '[QO100-Communication Satellite]'
    description: QO100 BPSK RX Beacon shift lock algorithm. Output rate matches input rate (samp_rate). Internal beacon tracking runs at samp_rate/decimation for efficiency, error signal is interpolated back to samp_rate before VCO.
    generate_options: hb
    id: RXSync
    output_language: python
    title: QO100 Beacon Tracker
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rs_taps_dec
  id: variable
  parameters:
    comment: Explicit taps for decim resampler
    value: firdes.low_pass(decimation, samp_rate, samp_rate/(2*decimation)*0.9, samp_rate/(2*decimation)*0.1, window.WIN_HAMMING)
  states: {}
- name: rs_taps_int
  id: variable
  parameters:
    comment: Explicit taps for interp resampler
    value: firdes.low_pass(decimation, samp_rate, samp_rate/(2*decimation)*0.9, samp_rate/(2*decimation)*0.1, window.WIN_HAMMING)
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '10'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: (-1*expected_beacon_freq)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: beacontrack_bw
  id: parameter
  parameters:
    label: Filter Bandwith
    type: eng_float
    value: '5000'
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    comment: VCO runs at samp_rate
    samp_rate: samp_rate
    sensitivity: '-1*(samp_rate/decimation)'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Costas runs at samp_rate/decimation
    order: '2'
    w: loop_bw
  states: {}
- name: enable
  id: parameter
  parameters:
    label: Enable
    type: intx
    value: '0'
  states: {}
- name: expected_beacon_freq
  id: parameter
  parameters:
    label: Expected Freq
    type: eng_float
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: expected_beacon_freq
    comment: Channelizer at samp_rate/decimation
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate/decimation, beacontrack_bw/2, 500, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: loop_bw
  id: parameter
  parameters:
    label: Costas Loop BW
    type: eng_float
    value: '0.015'
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_costas
  id: pad_sink
  parameters:
    label: costas_out
    type: complex
  states: {}
- name: pad_sink_filtered
  id: pad_sink
  parameters:
    label: filtered_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    comment: Input at samp_rate
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: decimation
    taps: rs_taps_int
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '960000'
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0_0, '0', blocks_selector_0, '1']
- [blocks_multiply_xx_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_selector_0, '0', pad_sink_0_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_1, '0']
- [digital_costas_loop_cc_0, '0', pad_sink_costas, '0']
- [digital_costas_loop_cc_0, '1', rational_resampler_xxx_0, '0']
- [digital_costas_loop_cc_0, '2', blocks_null_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', pad_sink_filtered, '0']
- [pad_source_0, '0', blocks_multiply_xx_0_0, '1']
- [pad_source_0, '0', blocks_selector_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_vco_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
