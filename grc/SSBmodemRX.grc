options:
  parameters:
    author: Vatan Zengin TA7WRS
    category: '[QO100-Communication Satellite]'
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3.
    generate_options: hb
    id: QO100_SSBModem_RX
    output_language: python
    title: SSB Receiver for QO100 Satellite
  states: {}

blocks:
- name: bb_samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: af_gain
  id: parameter
  parameters:
    comment: AF/speaker volume
    label: AF gain
    type: eng_float
    value: '0.5'
  states: {}
- name: agc_attack
  id: parameter
  parameters:
    comment: AGC attack rate
    label: AGC attack
    type: eng_float
    value: '0.0008'
  states: {}
- name: agc_decay
  id: parameter
  parameters:
    comment: AGC decay rate
    label: AGC decay
    type: eng_float
    value: '0.00006'
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    comment: AGC initial gain
    label: AGC init gain
    type: eng_float
    value: '1.0'
  states: {}
- name: agc_max_gain
  id: parameter
  parameters:
    comment: AGC max gain ceiling
    label: AGC max gain
    type: eng_float
    value: '3'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    comment: AGC reference level
    label: AGC ref
    type: eng_float
    value: '0.5'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_attack
    comment: RX baseband AGC (complex)
    decay_rate: agc_decay
    gain: agc_gain
    max_gain: agc_max_gain
    reference: agc_ref
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: sql_alpha
    gate: 'True'
    ramp: sql_ramp
    threshold: sql_thresh
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(fine_tune + freq_offset)'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: dev_name
    samp_rate: bb_samp_rate
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: RX baseband BPF
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: '200'
    samp_rate: bb_samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: enable
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: AF volume
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dev_name
  id: parameter
  parameters:
    label: Device Name
    value: '''pulse'''
  states: {}
- name: enable
  id: parameter
  parameters:
    label: Enable(1/0)
    type: intx
    value: '1'
  states: {}
- name: fine_tune
  id: parameter
  parameters:
    comment: RX fine tune (Hz, 1Hz step)
    label: Fine tune (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    comment: TX RF offset (loopback)
    label: Freq offset (Hz)
    type: eng_float
    value: '1500'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: view
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/bb_samp_rate)
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '960000'
  states: {}
- name: sql_alpha
  id: parameter
  parameters:
    comment: Squelch power averaging alpha
    label: Squelch alpha
    type: eng_float
    value: '0.001'
  states: {}
- name: sql_ramp
  id: parameter
  parameters:
    comment: Squelch ramp samples (~ms @ 24k)
    label: Squelch ramp
    type: intx
    value: '4800'
  states: {}
- name: sql_thresh
  id: parameter
  parameters:
    comment: Squelch threshold dB
    label: Squelch (dB)
    type: eng_float
    value: '-49'
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', blocks_complex_to_real_0, '0']
- [analog_agc2_xx_0_0, '0', pad_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_1, '0', analog_agc2_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [pad_source_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_1, '0', band_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
