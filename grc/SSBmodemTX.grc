options:
  parameters:
    author: Vatan Zengin TA7WRS
    category: '[QO100-Communication Satellite]'
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3.
    generate_options: hb
    id: QO100_SSBModem_TX
    output_language: python
    title: SSB Transmitter for QO100 Satellite
  states: {}

blocks:
- name: bb_samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: agc_attack
  id: parameter
  parameters:
    comment: AGC attack rate
    label: AGC attack
    type: eng_float
    value: '0.0008'
  states: {}
- name: agc_decay
  id: parameter
  parameters:
    comment: AGC decay rate
    label: AGC decay
    type: eng_float
    value: '0.00006'
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    comment: AGC initial gain
    label: AGC init gain
    type: eng_float
    value: '1.0'
  states: {}
- name: agc_max_gain
  id: parameter
  parameters:
    comment: AGC max gain ceiling
    label: AGC max gain
    type: eng_float
    value: '3'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    comment: AGC reference level
    label: AGC ref
    type: eng_float
    value: '0.5'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_attack
    comment: TX mic AGC (float)
    decay_rate: agc_decay
    gain: agc_gain
    max_gain: agc_max_gain
    reference: agc_ref
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: dev_name
    samp_rate: bb_samp_rate
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    comment: Mic input BPF
    gain: '1'
    high_cutoff_freq: '2700'
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: bb_samp_rate
    type: interp_fir_filter_fff
    width: '150'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: txenable
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(tx_gain, 0)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dev_name
  id: parameter
  parameters:
    label: Device Name
    value: '''pulse'''
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    comment: TX RF offset (loopback)
    label: Freq offset (Hz)
    type: eng_float
    value: '1500'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    beta: '7.0'
    num_taps: '201'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: view
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: int(samp_rate/bb_samp_rate)
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '960000'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    comment: TX drive level
    label: TX gain
    type: eng_float
    value: '0.15'
  states: {}
- name: txenable
  id: parameter
  parameters:
    label: Transmit Enable(1/0)
    type: intx
    value: '0'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', band_pass_filter_2, '0']
- [band_pass_filter_2, '0', analog_agc2_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', hilbert_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [hilbert_fc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
