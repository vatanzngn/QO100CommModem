options:
  parameters:
    author: Vatan Zengin
    category: '[QO100-Communication Satellite]'
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3.
    generate_options: hb
    id: QO100_QPSKDataModem_TX_nofec
    output_language: python
    title: QPSK DataModem TX NoFEC
  states: {}

blocks:
- name: bb_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: constel
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, -1+1j, -1-1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '384'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[192, 175]'
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_additive_scrambler_xx_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    len_tag_key: packet_len
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Stream Continuous Padder - Vatan Z. (v3)
      Burst stream in, continuous stream out (zero-padded when no input).
      Uses gr.basic_block + forecast()=[0] to allow output without input.
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Stream Continuous Padder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.fifo = np.array([], dtype=np.complex64)

          def forecast(self, noutput_items, ninputs):
              return [0]

          def general_work(self, input_items, output_items):
              out = output_items[0]
              n_out = len(out)

              if len(input_items) > 0 and len(input_items[0]) > 0:
                  inp = input_items[0]
                  n_in = len(inp)
                  self.fifo = np.append(self.fifo, inp)
                  self.consume(0, n_in)

              fifo_len = len(self.fifo)
              if fifo_len >= n_out:
                  out[:] = self.fifo[:n_out]
                  self.fifo = self.fifo[n_out:]
              elif fifo_len > 0:
                  out[:fifo_len] = self.fifo
                  out[fifo_len:] = 0
                  self.fifo = np.array([], dtype=np.complex64)
              else:
                  out[:] = 0

              return n_out
  states: {}
- name: freq_offs
  id: parameter
  parameters:
    label: Frequency Offset
    type: intx
    value: '0'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: TX Gain
    type: eng_float
    value: '0.5'
  states: {}
- name: network_socket_pdu_0_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: str(port)
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: carries FEC encoded payload
    tag: packet_len
    type: byte
  states: {}
- name: port
  id: parameter
  parameters:
    label: TX Port
    type: intx
    value: '5001'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/bb_samp_rate)
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '960000'
  states: {}
- name: sdr_tx
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: packaged_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: packaged_data
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', epy_block_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0_0, '0', blocks_tagged_stream_mux_0_1, '3']
- [blocks_stream_to_tagged_stream_0_0_0_0_1, '0', blocks_tagged_stream_mux_0_1, '0']
- [blocks_tagged_stream_mux_0_1, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_stream_to_tagged_stream_0_0_0_0_1, '0']
- [digital_additive_scrambler_xx_0, '0', blocks_tagged_stream_mux_0_1, '2']
- [digital_additive_scrambler_xx_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_1, '1']
- [epy_block_0, '0', sdr_tx, '0']
- [network_socket_pdu_0_0_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_additive_scrambler_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
