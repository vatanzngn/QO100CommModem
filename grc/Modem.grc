options:
  parameters:
    author: Vatan Zengin TA7WRS
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3. Read LISANCE.
    description: https://github.com/vatanzngn/QO100DataModem
    generate_options: qt_gui
    id: modem
    output_language: python
    title: QO100Modem-NOTXSync
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: AF gain
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.5'
  states: {}
- name: agc_attack
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: AGC attack
    start: '0.0001'
    step: '0.0001'
    stop: '0.05'
    value: '0.0008'
  states: {}
- name: agc_decay
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: AGC decay
    start: '0.00001'
    step: '0.00001'
    stop: '0.01'
    value: '0.00006'
  states: {}
- name: agc_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: AGC init gain
    start: '0.01'
    step: '0.01'
    stop: '5.0'
    value: '1.0'
  states: {}
- name: agc_max_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: AGC max gain
    start: '1'
    step: '0.5'
    stop: '100'
    value: '3'
  states: {}
- name: agc_ref
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: AGC ref
    start: '0.1'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: audio_dev_name
  id: variable
  parameters:
    value: '"default"'
  states: {}
- name: bt_expected_beacon_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Expected Freq
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: bt_filter_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Filter Bandwith
    start: '1000'
    step: '100'
    stop: '10000'
    value: '1500'
  states: {}
- name: bt_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Costas Loop BW
    start: '0.0001'
    step: '0.0001'
    stop: '0.02'
    value: '0.005'
  states: {}
- name: fine_tune
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Fine tune (Hz)
    min_len: '300'
    start: '-200'
    step: '1'
    stop: '200'
    value: '0'
  states: {}
- name: foff_data_ch1
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@3:[0,1,1,1]
    label: T-Data Freq Offs
    type: int
    value: '-124800'
  states: {}
- name: foff_ssb_ch1
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@2
    label: T-SSB Freq Offs
    type: int
    value: '50000'
  states: {}
- name: lower_int
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Waterfall Lower Color Intensity
    start: '-150'
    step: '1'
    stop: '-80'
    value: '-112'
  states: {}
- name: qpsk_chan_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[4,1,1,1]
    label: QPSK Channel BW (Hz)
    min_len: '250'
    start: '500'
    step: '100'
    stop: '5000'
    value: '2800'
  states: {}
- name: qpsk_rrc_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[5,0,1,2]
    label: QPSK RRC Alpha
    min_len: '250'
    start: '0.1'
    step: '0.05'
    stop: '0.9'
    value: '0.35'
  states: {}
- name: qpsk_symsync_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[3,0,1,1]
    label: QPSK Symbol Sync BW
    min_len: '250'
    start: '0.001'
    step: '0.001'
    stop: '0.05'
    value: '0.008'
  states: {}
- name: qpsk_symsync_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[3,1,1,1]
    label: QPSK Symbol Sync MaxDev
    min_len: '250'
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: qpsk_ted_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[4,0,1,1]
    label: QPSK TED Gain
    min_len: '250'
    start: '0.1'
    step: '0.05'
    stop: '2.0'
    value: '0.5'
  states: {}
- name: qpsk_tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[2,0,1,2]
    label: TX Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: qpskrx_costas_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3:[0,0,1,1]
    label: QPSK Costas Loop BW
    start: '0.002'
    step: '0.002'
    stop: '0.15'
    value: '0.02'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '65'
    value: '8'
  states: {}
- name: rx_lo
  id: variable
  parameters:
    value: '739750000'
  states: {}
- name: rx_lo
  id: variable
  parameters:
    value: '1200000000'
  states: {state: disabled}
- name: rxsync_enable
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tabs@0
    label: RXSync Enable
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: sdr_ip
  id: variable
  parameters:
    value: '"ip:192.168.1.42"'
  states: {}
- name: sdr_ip
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {state: disabled}
- name: sql_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Squelch alpha
    start: '0.0001'
    step: '0.0001'
    stop: '0.1'
    value: '0.001'
  states: {}
- name: sql_ramp
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Squelch ramp
    rangeType: int
    start: '0'
    step: '100'
    stop: '12000'
    value: '4800'
  states: {}
- name: sql_thresh
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-49'
  states: {}
- name: ssb_enable
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tabs@2
    label: SSB Enable
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: ssb_tx_enable
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tabs@2
    label: SSB PTT
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: ssb_tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: TX gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: tx_att
  id: variable_qtgui_range
  parameters:
    label: TX Attenuation !
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '16'
  states: {}
- name: tx_lo
  id: variable
  parameters:
    value: '1200000000'
  states: {state: disabled}
- name: tx_lo
  id: variable
  parameters:
    value: '2400250000'
  states: {}
- name: txsync_caltone_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Caltone Freq
    start: '-400000'
    step: '1'
    stop: '400000'
    value: '35000'
  states: {}
- name: txsync_debtone_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: TX Sync Debug Tone Offset
    start: '-4000'
    step: '1'
    stop: '4000'
    value: '0'
  states: {}
- name: txsync_enable
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tabs@1
    label: TX Sync Tone Enable
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: txsync_txlo_drift
  id: variable_qtgui_range
  parameters:
    label: Clock Drift Amount
    start: '-1500'
    step: '1'
    stop: '1500'
    value: '0'
  states: {}
- name: upper_int
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Waterfall Upper Color Intensity
    start: '-80'
    step: '1'
    stop: '40'
    value: '-70'
  states: {}
- name: QO100_QPSKDataModem_RX_nofec_0
  id: QO100_QPSKDataModem_RX_nofec
  parameters:
    chan_bw: '1500'
    costas_bw: qpskrx_costas_bw
    freq_offset: foff_data_ch1
    logport: '5002'
    port1: '5003'
    port2: '5004'
    port3: '5005'
    port4: '5006'
    rrc_alpha: '0.35'
    samp_rate: '960000'
    symsync_bw: '0.008'
    symsync_dev: '0.01'
    ted_gain: '0.5'
  states: {}
- name: QO100_QPSKDataModem_TX_nofec_0
  id: QO100_QPSKDataModem_TX_nofec
  parameters:
    freq_offs: foff_data_ch1
    gain: qpsk_tx_gain
    port: '5001'
    samp_rate: '960000'
  states: {}
- name: QO100_SSBModem_RX_0
  id: QO100_SSBModem_RX
  parameters:
    af_gain: af_gain
    agc_attack: agc_attack
    agc_decay: agc_decay
    agc_gain: agc_gain
    agc_max_gain: agc_max_gain
    agc_ref: agc_ref
    dev_name: audio_dev_name
    enable: ssb_enable
    fine_tune: fine_tune
    freq_offset: foff_ssb_ch1
    samp_rate: samp_rate
    sql_alpha: sql_alpha
    sql_ramp: sql_ramp
    sql_thresh: sql_thresh
  states: {}
- name: QO100_SSBModem_TX_0
  id: QO100_SSBModem_TX
  parameters:
    agc_attack: agc_attack
    agc_decay: agc_decay
    agc_gain: agc_gain
    agc_max_gain: agc_max_gain
    agc_ref: agc_ref
    dev_name: audio_dev_name
    freq_offset: foff_ssb_ch1
    samp_rate: samp_rate
    tx_gain: ssb_tx_gain
    txenable: ssb_tx_enable
  states: {}
- name: QO100_TXSyncCal_RX_0
  id: QO100_TXSyncCal_RX
  parameters:
    cal_tone: txsync_caltone_freq
  states: {}
- name: QO100_TXSyncCal_TX_0
  id: QO100_TXSyncCal_TX
  parameters:
    cal_tone: txsync_caltone_freq
    debug_tone_offset: txsync_debtone_freq
    enable: txsync_enable
  states: {}
- name: RXSync_0
  id: RXSync
  parameters:
    beacontrack_bw: bt_filter_bw
    enable: rxsync_enable
    expected_beacon_freq: bt_expected_beacon_freq
    loop_bw: bt_loop_bw
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: txsync_txlo_drift*(-1)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/vatanz/Desktop/recaksamfinal
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/media/vatanz/6AAA-F9E0/QO100/record/grcrecord_sep17_01.30
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att
    bandwidth: '1500000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_lo
    samplerate: samp_rate
    type: fc32
    uri: sdr_ip
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_lo
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: sdr_ip
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0
  id: note
  parameters:
    note: SDR Configurations
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: SSB Parameters
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: RX Sync Params
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: TX Sync Params
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'DAT MIN : -170.000'
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: 'DAT MAX : -100.000'
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: 'TR SSB : 27.000'
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: 'Center Freq : 10.489.750.000'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@3:[1,0,1,1]
    legend: 'False'
    name: '"Modem 1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '8000'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@1
    legend: 'False'
    name: '"Measurement Window"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@1
    label1: TX Freq Error
    max: '+4000'
    min: '-4000'
    name: '"TX Freq Error"'
    type: float
    unit1: Hz
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '24000'
    fc: '0'
    fftsize: '512'
    gui_hint: tabs@2:[1,1,1,1]
    name: SSB Audio RX
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '24000'
    fc: '0'
    fftsize: '512'
    gui_hint: tabs@2:[1,0,1,1]
    name: SSB Audio TX
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: (2,0,1,2)
    int_max: upper_int
    int_min: lower_int
    legend: 'False'
    name: ''
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_1_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/10)
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@0:(3,0,1,1)
    int_max: upper_int
    int_min: lower_int
    label1: costas
    legend: 'False'
    name: '"Filtered Signal"'
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_waterfall_sink_x_1_0_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@0:(3,1,1,1)
    int_max: upper_int
    int_min: lower_int
    label1: costas
    name: '"Costas Output"'
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_waterfall_sink_x_1_0_0_1_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@3:[1,1,1,1]
    int_max: upper_int
    int_min: lower_int
    label1: costas
    legend: 'False'
    name: ''
    type: complex
    update_time: '0.2'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: RX Sync
    label1: TX Sync
    label2: SSB Control
    label3: QPSK Flow
    num_tabs: '4'
  states: {}

connections:
- [QO100_QPSKDataModem_RX_nofec_0, '0', qtgui_const_sink_x_1, '0']
- [QO100_QPSKDataModem_RX_nofec_0, '1', qtgui_waterfall_sink_x_1_0_0_1_0_1, '0']
- [QO100_QPSKDataModem_TX_nofec_0, '0', blocks_add_xx_0, '1']
- [QO100_SSBModem_RX_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [QO100_SSBModem_TX_0, '0', blocks_add_xx_0, '2']
- [QO100_SSBModem_TX_0, '1', qtgui_waterfall_sink_x_0_0_0, '0']
- [QO100_TXSyncCal_RX_0, '0', qtgui_number_sink_0, '0']
- [QO100_TXSyncCal_RX_0, '1', qtgui_freq_sink_x_0, '0']
- [QO100_TXSyncCal_TX_0, '0', blocks_add_xx_0, '0']
- [RXSync_0, '0', QO100_QPSKDataModem_RX_nofec_0, '0']
- [RXSync_0, '0', QO100_SSBModem_RX_0, '0']
- [RXSync_0, '0', QO100_TXSyncCal_RX_0, '0']
- [RXSync_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [RXSync_0, '1', qtgui_waterfall_sink_x_1_0_0_1_0_0, '0']
- [RXSync_0, '2', qtgui_waterfall_sink_x_1_0_0_1_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_throttle2_0, '0', RXSync_0, '0']
- [iio_pluto_source_0, '0', RXSync_0, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
