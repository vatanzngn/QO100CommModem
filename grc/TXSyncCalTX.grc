options:
  parameters:
    author: Vatan Zengin TA7WRS
    category: '[QO100-Communication Satellite]'
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3.
    description: TX calibration tone generator. Tone amplitude is gated by enable.
    generate_options: hb
    id: QO100_TXSyncCal_TX
    output_language: python
    title: TX Sync Calibrator - TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: SDR sample rate
    value: '960000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: debug_tone_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: cal_tone
  id: parameter
  parameters:
    label: Cal Tone (Hz)
    type: intx
    value: '10000'
  states: {}
- name: debug_tone_offset
  id: parameter
  parameters:
    label: Debug Tone Offset (Hz)
    type: intx
    value: '0'
  states: {}
- name: enable
  id: parameter
  parameters:
    label: Cal Enable (1/0)
    type: intx
    value: '0'
  states: {}
- name: sig_ref
  id: analog_sig_source_x
  parameters:
    amp: enable
    comment: cal tone, amp = enable
    freq: cal_tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tx_out
  id: pad_sink
  parameters:
    label: tx_out
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', tx_out, '0']
- [sig_ref, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
