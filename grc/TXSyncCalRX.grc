options:
  parameters:
    author: Vatan Zengin TA7WRS
    category: '[QO100-Communication Satellite]'
    copyright: Copyright (c) 2026 Vatan Zengin. Licensed under GPL v3.
    description: TX frequency offset measurement. Delay-conjugate FLL discriminator over a 4 kHz window.
    generate_options: hb
    id: QO100_TXSyncCal_RX
    output_language: python
    title: TX Sync Calibrator - RX
  states: {}

blocks:
- name: avg_len
  id: variable
  parameters:
    comment: 4000 samples @8k = 0.5 s
    value: '4000'
  states: {}
- name: dec1
  id: variable
  parameters:
    comment: 960k -> 48k
    value: '20'
  states: {}
- name: dec2
  id: variable
  parameters:
    comment: 48k -> 8k
    value: '6'
  states: {}
- name: fs_meas
  id: variable
  parameters:
    comment: measrate
    value: samp_rate/(dec1*dec2)
  states: {}
- name: hz_scale
  id: variable
  parameters:
    comment: rad/sample -> Hz
    value: fs_meas/(2*math.pi)
  states: {}
- name: meas_bw
  id: variable
  parameters:
    comment: measurement window = 4 kHz
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: SDR sample rate
    value: '960000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: rad/sample
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: D = 1 sample
    delay: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: coherent averaging before arg()
    length: avg_len
    max_iter: '8192'
    scale: 1.0/avg_len
    type: complex
  states: {}
- name: blocks_multiply_const_hz
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad/sample -> Hz
    const: hz_scale
    type: float
  states: {}
- name: blocks_multiply_fd
  id: blocks_multiply_xx
  parameters:
    comment: x[n] * conj(x[n-1])
    type: complex
  states: {}
- name: cal_tone
  id: parameter
  parameters:
    label: Cal Tone (Hz)
    type: intx
    value: '10000'
  states: {}
- name: freq_err
  id: pad_sink
  parameters:
    comment: measured TX offset (Hz)
    label: freq_err
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: cal_tone
    comment: shift cal tone to DC, 960k -> 48k
    decim: dec1
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 4000, 4000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 4 kHz measurement window, 48k -> 8k
    cutoff_freq: meas_bw/2
    decim: dec2
    gain: '1'
    samp_rate: samp_rate/dec1
    type: fir_filter_ccf
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: meas_win
  id: pad_sink
  parameters:
    comment: 8 kHz measurement window (for freq sink)
    label: meas_win
    optional: 'True'
    type: complex
  states: {}
- name: rx_in
  id: pad_source
  parameters:
    comment: from RXSync output
    label: rx_in
    type: complex
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_hz, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_fd, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_hz, '0', freq_err, '0']
- [blocks_multiply_fd, '0', blocks_moving_average_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_fd, '0']
- [low_pass_filter_0, '0', meas_win, '0']
- [rx_in, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
